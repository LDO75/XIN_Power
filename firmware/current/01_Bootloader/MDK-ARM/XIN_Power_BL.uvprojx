# Keil uVision project XIN_Power_BL.uvprojx, settings and files
target XIN_Power_BL (6240000::V6.24::ARMCLANG)
  device: PY32F403xD Puya
  pack: Puya.PY32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: XIN_Power_BL +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PY32F403xD,USE_HAL_DRIVER
  c include: ../Core/INC;../Drivers/CMSIS/Include;../Drivers/PY32F403_HAL_Driver/Inc;../Drivers/CMSIS/Device/PY32F403/Include
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Bootloader
    ../: boot_main.c system_py32f403.c
    ./: boot_jump.s startup_py32f403.s
    ../Core/SRC/: w25q256.c ota_storage.c
    ../Drivers/PY32F403_HAL_Driver/Src/: py32f403_hal.c py32f403_hal_cortex.c py32f403_hal_gpio.c py32f403_hal_spi.c py32f403_hal_flash.c py32f403_hal_dma.c
