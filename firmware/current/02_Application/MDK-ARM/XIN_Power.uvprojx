# Keil uVision project XIN_Power.uvprojx, settings and files
target XIN_Power (6240000::V6.24::ARMCLANG)
  device: PY32F403xD Puya
  pack: Puya.PY32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08008000,0x00058000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XIN_Power +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PY32F403xD,USE_HAL_DRIVER
  c include: ../Core/INC;../Drivers/CMSIS/Include;../Drivers/PY32F403_HAL_Driver/Inc;../Drivers/CMSIS/Device/PY32F403/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x58000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Drivers/PY32F403_HAL_Driver
    ../Drivers/PY32F403_HAL_Driver/Src/: py32f403_hal_rcc.c py32f403_hal_rcc_ex.c py32f403_hal_pwr.c py32f403_hal_pwr_ex.c py32f403_hal_exti.c py32f403_hal_gpio.c py32f403_hal_dma.c py32f403_hal_spi.c py32f403_hal_tim.c py32f403_hal_tim_ex.c py32f403_hal_i2c.c py32f403_hal_adc.c py32f403_hal_adc_ex.c py32f403_hal_usart.c py32f403_hal_smartcard.c py32f403_hal_irda.c py32f403_hal_uart.c py32f403_hal.c py32f403_hal_cortex.c
  group Application/User/Core
    ../Core/SRC/: rcc.c gpio.c py32f403_it.c spi.c tim.c i2c.c adc.c main.c py32f403_hal_msp.c dma.c usart.c wire_protocol.c
  group Application/DebugConsole
    ../Core/SRC/: debug_console.c
    ../Core/INC/: debug_console.h
  group Application/UI
    ../Core/SRC/: ui_page.c ui_layout.c
    ../Core/INC/: ui_page.h ui_layout.h ui_config.h
  group BSP/Display
    ../Core/SRC/: splash_logo.c splash_logo_data.c lcd.c
    ../Core/INC/: splash_logo.h lcd.h
  group BSP/Touch
    ../Core/SRC/: cst836u.c
    ../Core/INC/: cst836u.h
  group BSP/Audio
    ../Core/SRC/: buzzer.c
    ../Core/INC/: buzzer.h
  group BSP/PowerMonitor
    ../Core/SRC/: ina226.c power_monitor.c
    ../Core/INC/: ina226.h power_monitor.h
  group BSP/Temperature
    ../Core/SRC/: temperature_sensor.c
    ../Core/INC/: temperature_sensor.h
  group BSP/DAC
    ../Core/SRC/: mcp4725.c
    ../Core/INC/: mcp4725.h
  group BSP/ExternalFlash
    ../Core/SRC/: w25q256.c
    ../Core/INC/: w25q256.h
  group Application/PowerControl
    ../Core/SRC/: calibration.c user_settings.c power_control.c fan_control.c
    ../Core/INC/: calibration.h user_settings.h power_control.h fan_control.h power_config.h
  group Application/OTA
    ../Core/SRC/: ota_storage.c ota_updater.c
    ../Core/INC/: ota_layout.h ota_storage.h ota_updater.h firmware_version.h
  group Application/MDK
    ./: startup_py32f403.s
  group Drivers/CMSIS
    ../Core/SRC/: system_py32f403.c
